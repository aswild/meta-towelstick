# Don't auto-start sshd, since towelstick has no root password
SYSTEMD_AUTO_ENABLE = "disable"
