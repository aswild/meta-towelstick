# Towelstick uses real coreutils and such, keep busybox out
RDEPENDS_${PN}_remove = "busybox"
