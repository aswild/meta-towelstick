inherit packagegroup

RDEPENDS_${PN} = " \
    clonezilla \
    mtools \
    ntfs-3g \
    partclone \
    partimage \
    sshfs-fuse \
"
